require petalinux-image-full-vitis.inc

IMAGE_INSTALL:append = " python3-pybind11"
