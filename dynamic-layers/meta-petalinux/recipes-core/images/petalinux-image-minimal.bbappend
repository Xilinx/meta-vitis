require petalinux-image-common-vitis.inc
