RDEPENDS:${PN}:append:linux = " \
    nativesdk-protobuf \
    nativesdk-protobuf-c \
    nativesdk-protobuf-compiler \
    nativesdk-protobuf-dev \
"
